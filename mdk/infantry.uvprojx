# Keil uVision project infantry.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Belief exp2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,ROBOT_LOOP_ONE.__TARGET_FPU_CM4,ARM_MATH_CM4,__CC_ARM
  c misc: --gnu
  c include: ..\core;..\bsp\inc;..\driver\inc;..\library\std\inc;..\user;..\library\freertos\include;..\library\freertos\portable\RVDS\ARM_CM4F;..\user\common;..\library\atom\delay;..\library\atom\sys;..\library\atom\usart;..\library\atom\debug;..\library\mpu6500;..\user\infantry;..\library\vegmath;..\user\common;..\device\inc;..\library\ekf;..\library\vl53l1x\core;..\library\vl53l1x\platform
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f427xx.s
  group library
    ../library/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../library/freertos/portable/MemMang/: heap_4.c
    ../library/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../library/atom/delay/: delay.c
    ../library/atom/sys/: sys.c
    ../library/mpu6500/: MadgwickAHRS.c mpu6500_driver.c mpu6500_i2c.c
    ../library/atom/debug/: beep.c key.c led.c
    ../library/vegmath/: vegmath.c
    ../library/atom/usart/: usart.c
    ../library/ekf/: gyro_bias_estimator.c orientation_ekf.c low_pass_filter.c matrix3x3d.c so3_helper.c vector3d.c
    ../library/vl53l1x/core/: VL53L1X_api.c VL53L1X_calibration.c
    ../library/vl53l1x/platform/: vl53l1_platform.c
  group driver
    ../driver/src/: Driver_CAN.c Driver_DBUS.c Driver_PID.c Driver_Magic.c Driver_Chassis.c Driver_Motor.c Driver_Filter.c Driver_Gyroscope.c Driver_BSP.c Driver_Protocol.c Driver_Fsm.c Driver_Bridge.c Driver_Vofa.c Driver_MyChassis.c Driver_MyController.c Driver_MyCrane.c Driver_MyDelay.c Driver_MyI2C.c Driver_MySerial.c Driver_MyUSART.c Driver_MyTof.c Driver_MyMotor.c
    ../device/src/: Driver_MyDMA.c Driver_MyServo.c
    ../driver/inc/: Driver_MyChassis.h Driver_MyController.h Driver_MyCrane.h Driver_MyDelay.h Driver_MyDMA.h Driver_MyI2C.h Driver_MySerial.h Driver_MyServo.h Driver_MyTof.h Driver_MyUSART.h Driver_MyMotor.h
  group user_common
    ../user/common/: macro.h system_stm32f4xx.c interrupt.h
  group user_loop_infantry
    ../user/infantry/: interrupt.c main.c tasks.c
  group device
    ../device/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c
